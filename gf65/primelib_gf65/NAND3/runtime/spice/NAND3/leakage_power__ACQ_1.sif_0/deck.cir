.title leakage_power__ACQ_1

* state: !A&!C&!B&OUT
* state_coverage: 1

* Deck file generated by PrimeLib T-2022.03-SP1 build date: Apr 12, 2022 13:01:04. (SMSC-2)
* PrimeLib path: /proj/cad/synopsys/synopsys_2021/primelib/T-2022.03-SP1/linux64/bin/primelib
* Host Name: engnx02a.utdallas.edu, User Name: sxv240035, PID: 6277
* Directory: /var/tmp/primelib.engnx02a.860278.6277/NAND3/leakage_power__ACQ_1.sif_0

* Circuit simulation deck copyright (c) 1998-Present
* Synopsys Inc.  This file contains proprietary
* and confidential information.  All rights reserved.

* **************************
* Process Corner
* **************************

.include "/proj/cad/library/mosis/GF65_LPe/cmos10lpe_CDS_oa_dl064_11_20160415/models/YI-SM00030/Hspice/models/design.inc"

* **************************
* Temperature
* **************************

.temp 0

* **************************
* Options
* **************************

.option post=0
.option probe=1
.option numdgt=10 measdgt=10 autostop=1
.option ingold=1 lennam=16 nomod=1 brief=1 lislvl=1 statfl=1 warnlimit=5 pivot=0 symb=1 post_version=9601
.option measform=1
.option cell_char=yes
.option  post=1 runlvl=5 numdgt=7 measdgt=7 acct=1 nopage
.option measout=1 putmeas=0
.option post=0

.save TYPE=ic LEVEL=NONE
* **************************
* Parameters
* **************************

.param __dummy__ = 0
.param __param_a = 0
.param __param_b = 0
.param __param_c = 0
.param __param_vdd = 1.2
.param __param_vss = 0
.param ct = 6.4125e-08
.param default_slew = 1.5e-11
.param gate_leakage_multiplication_factor = 1
.param initial_delay = 1.78125e-08
.param load_out = 4e-14
.param load_vdd = 4e-14
.param load_vss = 4e-14
.param pp = 3.135e-08
.param temperature_tag = 0
.param trailing_delay = 6.27e-08
.param units = 6.4125e-08
.param end_time = 1.44644625e-07
.data arc_data
+ __dummy__ temperature_tag __param_vdd __param_vss
+ 0 0 1.2 0
.enddata

* **************************
* Global nodes
* **************************

* **************************
* Network
* **************************

.inc '/home/eng/s/sxv240035/cad/gf65/primelib_gf65/NAND3/netlists/NAND3.pex.sp'
xnand3_inst vss out vdd c b a NAND3
va_meter a a_harness dc 0
va_stim a_harness 0 dc 0
vb_meter b b_harness dc 0
vb_stim b_harness 0 dc 0
vc_meter c c_harness dc 0
vc_stim c_harness 0 dc 0
vout_meter out out_harness dc 0
vvdd_meter vdd vdd_harness dc 0
vvdd_stim vdd_harness 0 dc 1.2
cvdd_stim_cap vdd_harness 0 1e-15
vvss_meter vss vss_harness dc 0
vvss_stim vss_harness 0 dc 0
cvss_stim_cap vss_harness 0 1e-15
ccap_out out_harness vss 4e-14
ccap_vdd vdd_harness vss 4e-14
ccap_vss vss_harness vss 4e-14
* **************************
* Measurements
* **************************

.meas tran input_current_a avg i(va_stim) from=4.91625e-08 to=8.05125e-08
.meas tran input_current_b avg i(vb_stim) from=4.91625e-08 to=8.05125e-08
.meas tran input_current_c avg i(vc_stim) from=4.91625e-08 to=8.05125e-08
.meas tran input_voltage_a avg v(a_harness) from=4.91625e-08 to=8.05125e-08
.meas tran input_voltage_b avg v(b_harness) from=4.91625e-08 to=8.05125e-08
.meas tran input_voltage_c avg v(c_harness) from=4.91625e-08 to=8.05125e-08
.meas tran supply_current_vdd avg i(vvdd_stim) from=4.91625e-08 to=8.05125e-08
.meas tran supply_voltage_vdd avg v(vdd_harness) from=4.91625e-08 to=8.05125e-08
* **************************
* Analysis
* **************************

* Analysis.tranPlus.
.tran 1e-12 1.44644625e-07 sweep data=arc_data

.end
