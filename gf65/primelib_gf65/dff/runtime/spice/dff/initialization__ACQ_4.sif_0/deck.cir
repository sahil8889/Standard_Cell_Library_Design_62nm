.title initialization__ACQ_4

* state: 1
* state_coverage: 1

* Deck file generated by PrimeLib T-2022.03-SP1 build date: Apr 12, 2022 13:01:04. (SMSC-2)
* PrimeLib path: /proj/cad/synopsys/synopsys_2021/primelib/T-2022.03-SP1/linux64/bin/primelib
* Host Name: engnx02a.utdallas.edu, User Name: sxv240035, PID: 30629
* Directory: /var/tmp/primelib.engnx02a.860278.30629/dff/initialization__ACQ_4.sif_0

* Circuit simulation deck copyright (c) 1998-Present
* Synopsys Inc.  This file contains proprietary
* and confidential information.  All rights reserved.

* **************************
* Process Corner
* **************************

.include "/proj/cad/library/mosis/GF65_LPe/cmos10lpe_CDS_oa_dl064_11_20160415/models/YI-SM00030/Hspice/models/design.inc"

* **************************
* Temperature
* **************************

.temp 0

* **************************
* Options
* **************************

.option post=0
.option probe=1
.option numdgt=10 measdgt=10 autostop=1
.option ingold=1 lennam=16 nomod=1 brief=1 lislvl=1 statfl=1 warnlimit=5 pivot=0 symb=1 post_version=9601
.option measform=1
.option cell_char=yes
.option  post=1 runlvl=5 numdgt=7 measdgt=7 acct=1 nopage
.option measout=1 putmeas=0
.option probe=0
.option post=0

.save TYPE=ic LEVEL=NONE
* **************************
* Parameters
* **************************

.param __dummy__ = 0
.param __param_d = 0
.param __param_r = 0
.param __param_vdd = 1.2
.param __param_vss = 0
.param ct = 6.4125e-08
.param default_slew = 1.5e-11
.param initial_delay = 1.78125e-08
.param load_q = 4e-14
.param load_vdd = 4e-14
.param load_vss = 4e-14
.param temperature_tag = 0
.param units = 6.4125e-08
.data arc_data
+ __dummy__ temperature_tag __param_vdd __param_vss
+ 0 0 1.2 0
.enddata

* **************************
* Global nodes
* **************************

* **************************
* Network
* **************************

.inc '/home/eng/s/sxv240035/cad/gf65/primelib_gf65/dff/netlists/dff.pex.sp'
xdff_inst dff vss clk q vdd d r dff
vclk_meter clk clk_harness dc 0
vd_meter d d_harness dc 0
vd_stim d_harness 0 dc 0
vq_meter q q_harness dc 0
vr_meter r r_harness dc 0
vr_stim r_harness 0 dc 0
vvdd_meter vdd vdd_harness dc 0
vvdd_stim vdd_harness 0 dc 1.2
cvdd_stim_cap vdd_harness 0 1e-15
vvss_meter vss vss_harness dc 0
vvss_stim vss_harness 0 dc 0
cvss_stim_cap vss_harness 0 1e-15
ccap_q q_harness vss 4e-14
ccap_vdd vdd_harness vss 4e-14
ccap_vss vss_harness vss 4e-14
vdff_meter dff dff_harness dc 0
vclk_stim clk_harness 0 pwl
+  0  1.2
+  1.78125e-08  1.2
+  1.78275e-08  0
+  8.19375e-08  0
* **************************
* Measurements
* **************************

.probe v(*) level=1
.save TYPE=ic FILE=deck.save LEVEL=ALL TIME=1.46083875e-07
* **************************
* Analysis
* **************************

* Analysis.tranPlus.
.tran 1e-12 1.46083875e-07 sweep data=arc_data

.end
