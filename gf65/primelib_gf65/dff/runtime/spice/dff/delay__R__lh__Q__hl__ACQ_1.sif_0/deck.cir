.title delay__R__lh__Q__hl__ACQ_1

* state: !CLK&!D
* state_coverage: 1

* Deck file generated by PrimeLib T-2022.03-SP1 build date: Apr 12, 2022 13:01:04. (SMSC-2)
* PrimeLib path: /proj/cad/synopsys/synopsys_2021/primelib/T-2022.03-SP1/linux64/bin/primelib
* Host Name: engnx02a.utdallas.edu, User Name: sxv240035, PID: 27982
* Directory: /var/tmp/primelib.engnx02a.860278.27982/dff/delay__R__lh__Q__hl__ACQ_1.sif_0

* Circuit simulation deck copyright (c) 1998-Present
* Synopsys Inc.  This file contains proprietary
* and confidential information.  All rights reserved.

* **************************
* Process Corner
* **************************

.include "/proj/cad/library/mosis/GF65_LPe/cmos10lpe_CDS_oa_dl064_11_20160415/models/YI-SM00030/Hspice/models/design.inc"

* **************************
* Temperature
* **************************

.temp 0

* **************************
* Options
* **************************

.option post=0
.option probe=1
.option numdgt=10 measdgt=10 autostop=1
.option ingold=1 lennam=16 nomod=1 brief=1 lislvl=1 statfl=1 warnlimit=5 pivot=0 symb=1 post_version=9601
.option measform=1
.option cell_char=yes
.option  post=1 runlvl=5 numdgt=7 measdgt=7 acct=1 nopage
.option measout=1 putmeas=0

.save TYPE=ic LEVEL=NONE
* **************************
* Parameters
* **************************

.param __param_clk = 0
.param __param_d = 0
.param __param_vdd = 1.2
.param __param_vss = 0
.param ct = 6.4125e-08
.param default_slew = 1.5e-11
.param energy_change_abs_threshold = 1e-12
.param energy_change_threshold = 0.05
.param initial_delay = 1e-11
.param load_q = 1e-14
.param load_vdd = 4e-14
.param load_vss = 4e-14
.param pp = 3.135e-08
.param slew_r = 1e-11
.param temperature_tag = 0
.param units = 6.4125e-08
.param end_time = 9.50006e-08
.data arc_data
+ slew_r load_q temperature_tag __param_vdd __param_vss
+ 1e-11 1e-14 0 1.2 0
+ 1e-11 1.3693981e-14 0 1.2 0
+ 1e-11 2.6660665e-14 0 1.2 0
+ 1e-11 5.1422412e-14 0 1.2 0
+ 1e-11 9e-14 0 1.2 0
+ 2.7273437e-10 1e-14 0 1.2 0
+ 2.7273437e-10 1.3693981e-14 0 1.2 0
+ 2.7273437e-10 2.6660665e-14 0 1.2 0
+ 2.7273437e-10 5.1422412e-14 0 1.2 0
+ 2.7273437e-10 9e-14 0 1.2 0
+ 1.1949898e-09 1e-14 0 1.2 0
+ 1.1949898e-09 1.3693981e-14 0 1.2 0
+ 1.1949898e-09 2.6660665e-14 0 1.2 0
+ 1.1949898e-09 5.1422412e-14 0 1.2 0
+ 1.1949898e-09 9e-14 0 1.2 0
+ 2.956169e-09 1e-14 0 1.2 0
+ 2.956169e-09 1.3693981e-14 0 1.2 0
+ 2.956169e-09 2.6660665e-14 0 1.2 0
+ 2.956169e-09 5.1422412e-14 0 1.2 0
+ 2.956169e-09 9e-14 0 1.2 0
+ 5.7e-09 1e-14 0 1.2 0
+ 5.7e-09 1.3693981e-14 0 1.2 0
+ 5.7e-09 2.6660665e-14 0 1.2 0
+ 5.7e-09 5.1422412e-14 0 1.2 0
+ 5.7e-09 9e-14 0 1.2 0
.enddata

* **************************
* Global nodes
* **************************

* **************************
* Network
* **************************

.inc '/home/eng/s/sxv240035/cad/gf65/primelib_gf65/dff/netlists/dff.pex.sp'
.ic
.inc '/home/eng/s/sxv240035/cad/gf65/primelib_gf65/dff/results/dff/initialization__ACQ_2.op_cond.initialization'
xdff_inst vss clk q vdd d r dff
vclk_meter clk clk_harness dc 0
vclk_stim clk_harness 0 dc 0
vd_meter d d_harness dc 0
vd_stim d_harness 0 dc 0
vq_meter q q_harness dc 0
vr_meter r r_harness dc 0
vvdd_meter vdd vdd_harness dc 0
vvdd_stim vdd_harness 0 dc 1.2
cvdd_stim_cap vdd_harness 0 1e-15
vvss_meter vss vss_harness dc 0
vvss_stim vss_harness 0 dc 0
cvss_stim_cap vss_harness 0 1e-15
ccap_q q_harness ground_q 'load_q'
ccap_vdd vdd_harness ground_vdd 4e-14
ccap_vss vss_harness ground_vss 4e-14
vcap_ground_q ground_q 0 dc 0
vcap_ground_vdd ground_vdd 0 dc 0
vcap_ground_vss ground_vss 0 dc 0
vr_stim r_harness 0 pwl
+  0  0
+  1e-11  0
+  '1e-11 + slew_r * 1.25'  1.2
+  3.136e-08  1.2
* **************************
* Measurements
* **************************

.meas tran cin__r__lh_trig when v(r)=0.06 cross=1 td=1e-11
.meas tran cin__r__lh_targ when v(r)=1.14 cross=1 td=1e-11
.meas tran cin__r__lh_q integ i(vr_meter) from='cin__r__lh_trig' to='cin__r__lh_targ'
* Return abs((Cin__R__lh_q)/(1.08))
.meas tran tin__r__lh_trig when v(r)=0.12 rise=1 td=1e-11
.meas tran tin__r__lh_targ when v(r)=1.08 rise=1 td=1e-11
* Return ((Tin__R__lh_targ)-(Tin__R__lh_trig))*(1)
.meas tran tout__q__hl_trig when v(q)=1.08 fall=1 td=1e-11
.meas tran tout__q__hl_targ when v(q)=0.12 fall=1 td=1e-11
* Return ((Tout__Q__hl_targ)-(Tout__Q__hl_trig))*(1)
.meas tran cap_energy__q__hl_vp0 find v(q_harness) at=1e-11
.meas tran cap_energy__q__hl_vp1 find v(q_harness) at=3.136e-08
.meas tran cap_energy__q__hl_vn0 find v(ground_q) at=1e-11
.meas tran cap_energy__q__hl_vn1 find v(ground_q) at=3.136e-08
* Return (((0.5)*(cap_Q.value))*(cap_energy__Q__hl_vp1-cap_energy__Q__hl_vn1-cap_energy__Q__hl_vp0+cap_energy__Q__hl_vn0))*(cap_energy__Q__hl_vp1-cap_energy__Q__hl_vn1-cap_energy__Q__hl_vp0+cap_energy__Q__hl_vn0)
.meas tran delay__r__lh__q__hl_trig when v(r)=0.6 rise=1 td=1e-11
.meas tran delay__r__lh__q__hl_targ when v(q)=0.6 fall=1 td=1e-11
* Return ((delay__R__lh__Q__hl_targ)-(delay__R__lh__Q__hl_trig))*(1)
.meas tran energy1__r__lh__q__hl__vdd_vdd_harness_v find v(vdd_harness) at=3.136e-08
.meas tran energy1__r__lh__q__hl__vdd_vdd_harness_q integ i(vvdd_stim) from=1e-11 to=3.136e-08
* Return (0)-((energy1__R__lh__Q__hl__VDD_VDD_harness_v)*(energy1__R__lh__Q__hl__VDD_VDD_harness_q))
.meas tran energy__r__lh__q__hl_vdd_harness_v find v(vdd_harness) at=3.136e-08
.meas tran energy__r__lh__q__hl_vdd_harness_q integ i(vvdd_stim) from=1e-11 to=3.136e-08
* Return (0)-((energy__R__lh__Q__hl_VDD_harness_v)*(energy__R__lh__Q__hl_VDD_harness_q))
.meas tran leakage_power1__vdd_vdd_harness_v avg v(vdd_harness) from=2.97925e-08 to=3.136e-08
.meas tran leakage_power1__vdd_vdd_harness_i avg i(vvdd_stim) from=2.97925e-08 to=3.136e-08
* Return (0)-((leakage_power1__VDD_VDD_harness_v)*(leakage_power1__VDD_VDD_harness_i))
.meas tran leakage_power2__vdd_vdd_harness_v avg v(vdd_harness) from=2.8225e-08 to=2.97925e-08
.meas tran leakage_power2__vdd_vdd_harness_i avg i(vvdd_stim) from=2.8225e-08 to=2.97925e-08
* Return (0)-((leakage_power2__VDD_VDD_harness_v)*(leakage_power2__VDD_VDD_harness_i))
* **************************
* Analysis
* **************************

* Analysis.tranPlus.
.tran 1e-12 9.50006e-08 sweep data=arc_data

.end
