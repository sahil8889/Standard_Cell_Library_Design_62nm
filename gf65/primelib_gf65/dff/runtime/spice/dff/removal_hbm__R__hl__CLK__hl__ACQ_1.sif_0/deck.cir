.title removal_hbm__R__hl__CLK__hl__ACQ_1

* state: D
* state_coverage: 1

* Deck file generated by PrimeLib T-2022.03-SP1 build date: Apr 12, 2022 13:01:04. (SMSC-2)
* PrimeLib path: /proj/cad/synopsys/synopsys_2021/primelib/T-2022.03-SP1/linux64/bin/primelib
* Host Name: engnx02a.utdallas.edu, User Name: sxv240035, PID: 30629
* Directory: /var/tmp/primelib.engnx02a.860278.30629/dff/removal_hbm__R__hl__CLK__hl__ACQ_1.sif_0

* Circuit simulation deck copyright (c) 1998-Present
* Synopsys Inc.  This file contains proprietary
* and confidential information.  All rights reserved.

* **************************
* Process Corner
* **************************

.include "/proj/cad/library/mosis/GF65_LPe/cmos10lpe_CDS_oa_dl064_11_20160415/models/YI-SM00030/Hspice/models/design.inc"

* **************************
* Temperature
* **************************

.temp 0

* **************************
* Model
* **************************

.model optmod opt METHOD = PASSFAIL ABSIN = 1e-11 ITROPT = 50

* **************************
* Options
* **************************

.option post=0
.option probe=1
.option numdgt=10 measdgt=10 autostop=1
.option ingold=1 lennam=16 nomod=1 brief=1 lislvl=1 statfl=1 warnlimit=5 pivot=0 symb=1 post_version=9601
.option measform=1
.option cell_char=yes
.option altcc=1 dynacc=1
.option mcbrief=5
.option  post=1 runlvl=5 numdgt=7 measdgt=7 acct=1 nopage
.option measout=1 putmeas=0
.option bisec_pushout_init=1 dynacc=0
.option extend_bisec_window=20

.save TYPE=ic LEVEL=NONE
* **************************
* Parameters
* **************************

.param __param_d = 1.2
.param ct = 6.4125e-08
.param default_slew = 1.5e-11
.param degrade_removal = 0
.param driver_delay_clk = 6.249999999999999e-12
.param driver_delay_r = 6.249999999999999e-12
.param glitch_threshold_q = 0.1
.param initial_delay = 1e-11
.param load_q = 4e-14
.param load_vdd = 4e-14
.param load_vss = 4e-14
.param max_removal = -8.55e-09
.param min_removal = 8.55e-09
.param opt_tolerance = 1e-11
.param removal = -8.55e-09
.param stable = 3.5625e-08
.param units = 6.4125e-08
* **************************
* HBM OPT PARAM
* **************************

.param removal = opt1('min_removal','init_hbm','init_hbm-1.99e-11-0.15*sis_exp_factor')

.param sis_exp_factor = '(0.3/0.3)*(slew_R+slew_CLK)'
.param sis_skip_first_iteration = '1'
.param M_constraint_CLK = '(removal>0)'
.param M_constraint = '(removal<0)'
* **************************
* Global nodes
* **************************

* **************************
* Network
* **************************

.inc '/home/eng/s/sxv240035/cad/gf65/primelib_gf65/dff/netlists/dff.pex.sp'
xdff_inst dff vss clk q vdd d r dff
vclk_meter clk clk_harness dc 0
vd_meter d d_harness dc 0
vd_stim d_harness 0 dc 1.2
vq_meter q q_harness dc 0
vr_meter r r_harness dc 0
vvdd_meter vdd vdd_harness dc 0
vvdd_stim vdd_harness 0 dc 1.2
cvdd_stim_cap vdd_harness 0 1e-15
vvss_meter vss vss_harness dc 0
vvss_stim vss_harness 0 dc 0
cvss_stim_cap vss_harness 0 1e-15
ccap_q q_harness vss 4e-14
ccap_vdd vdd_harness vss 4e-14
ccap_vss vss_harness vss 4e-14
vdff_meter dff dff_harness dc 0
vclk_stim clk_harness 0 pwl
+  0  1.2
+  '1e-11 - m_constraint * removal'  1.2
+  '1e-11 + slew_clk * 1.25 - m_constraint * removal'  0
+  '1e-11 - m_constraint * removal + 3.5625e-08'  0
vr_stim r_harness 0 pwl
+  0  1.2
+  '1e-11 + m_constraint_clk * removal'  1.2
+  '1e-11 + m_constraint_clk * removal + slew_r * 1.25'  0
+  '1e-11 + m_constraint_clk * removal + 3.5625e-08'  0
* **************************
* Measurements
* **************************

.meas tran tin__clk__hl_trig when v(clk)=1.08 fall=1 td='1e-11 - m_constraint * removal'
.meas tran tin__clk__hl_targ when v(clk)=0.12 fall=1 td='1e-11 - m_constraint * removal'
* Return ((Tin__CLK__hl_targ)-(Tin__CLK__hl_trig))*(1)
.meas tran tin__r__hl_trig when v(r)=1.08 fall=1 td='1e-11 + m_constraint_clk * removal'
.meas tran tin__r__hl_targ when v(r)=0.12 fall=1 td='1e-11 + m_constraint_clk * removal'
* Return ((Tin__R__hl_targ)-(Tin__R__hl_trig))*(1)
.meas tran glitch_check_hbm__clk__hl__q__lh_check MAX  v(q)  FROM =   '1e-11 - m_constraint * removal'
.meas tran glitch_check_hbm__clk__hl__q__lh_value PARAM = '(0.12 - glitch_check_hbm__CLK__hl__Q__lh_check)>0'
* Return glitch_check_hbm__CLK__hl__Q__lh_value
.meas tran removal_applied param='removal'
.meas tran removal_hbm__r__hl__clk__hl_trig when v(r)=0.6 fall=1 td='1e-11 + m_constraint_clk * removal'
.meas tran removal_hbm__r__hl__clk__hl_targ when v(clk)=0.6 fall=1 td='1e-11 - m_constraint * removal'
.meas tran removal_hbm__r__hl__clk__hl_value PARAM = 'removal_hbm__R__hl__CLK__hl_targ-removal_hbm__R__hl__CLK__hl_trig'
* Return removal_hbm__R__hl__CLK__hl_value
.meas tran sis_faillist PARAM = 'min(glitch_check_hbm__CLK__hl__Q__lh_value, 999)'
.meas tran sis_faillist_check FIND PAR('1') AT ='sis_faillist ? 0 : -1'
.meas tran sis_passlist PARAM = 'min(removal_hbm__R__hl__CLK__hl_trig, min(removal_hbm__R__hl__CLK__hl_targ, min(tin__R__hl_trig, min(tin__R__hl_targ, min(tin__CLK__hl_trig, tin__CLK__hl_targ)))))'
* **************************
* Analysis
* **************************

* Analysis.tranPlus.
.tran 1e-12 1.0795385e-07 sweep OPTIMIZE = opt1 RESULT = sis_passlist,sis_faillist_check MODEL = optmod data=arc_data

.data arc_data
+ slew_r slew_clk temperature_tag __param_vdd __param_vss init_hbm
+ 1e-11 1e-11 0 1.2 0 0
+ 1e-11 1.2715793e-09 0 1.2 0 7.884870625e-10
+ 1e-11 5.7e-09 0 1.2 0 3.55625e-09
+ 1.2715793e-09 1e-11 0 1.2 0 -7.884870625e-10
+ 1.2715793e-09 1.2715793e-09 0 1.2 0 0
+ 1.2715793e-09 5.7e-09 0 1.2 0 2.7677629375e-09
+ 5.7e-09 1e-11 0 1.2 0 -3.55625e-09
+ 5.7e-09 1.2715793e-09 0 1.2 0 -2.7677629375e-09
+ 5.7e-09 5.7e-09 0 1.2 0 0
.enddata

.end
